## boards/arm/zmk-rule60/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_ZMK_RULE60
    bool "zmk-rule60"
    depends on SOC_NRF52840_QIAA
```
